# Keil uVision project lib-ext-nordic.uvprojx, settings and files
target lib-nordic (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib-nordic-obj +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: WSF_ASSERT_ENABLED=1 MESH_NVM_USE_STUBS=1 SCH_CHECK_LIST_INTEGRITY=1 MESH_ENABLE_TEST=1 INIT_BROADCASTER LL_VER=LL_VER_BT_CORE_SPEC_4_2 INIT_OBSERVER INIT_ENCRYPTED BT_VER=9 uECC_ASM=2 INIT_PERIPHERAL WSF_BUF_STATS=1 INIT_CENTRAL BB_CLK_RATE_HZ=1000000
  c misc: --diag_suppress=1296,550,188
  c include: ..\..\..\..\ble-mesh-model\include;..\..\..\..\ble-mesh-model\include\app;..\..\..\..\ble-mesh-model\sources\apps;..\..\..\..\ble-mesh-model\sources\apps\app;..\..\..\..\ble-profiles\include\app;..\..\..\..\ble-profiles\sources\apps;..\..\..\..\ble-profiles\sources\apps\app;..\..\..\..\ble-mesh-model\include;..\..\..\..\ble-mesh-model\sources\models\include;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\bearer\adv;..\..\..\..\ble-mesh-profile\sources\bearer\gatt;..\..\..\..\ble-mesh-profile\sources\ble-profiles\profiles;..\..\..\..\ble-mesh-profile\sources\ble-profiles\services;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\stack\cfg;..\..\..\..\ble-mesh-profile\sources\stack\access;..\..\..\..\ble-mesh-profile\sources\stack\api;..\..\..\..\ble-mesh-profile\sources\stack\bearer;..\..\..\..\ble-mesh-profile\sources\stack\friend;..\..\..\..\ble-mesh-profile\sources\stack\include;..\..\..\..\ble-mesh-profile\sources\stack\local_config;..\..\..\..\ble-mesh-profile\sources\stack\lpn;..\..\..\..\ble-mesh-profile\sources\stack\network;..\..\..\..\ble-mesh-profile\sources\stack\security;..\..\..\..\ble-mesh-profile\sources\stack\seq_manager;..\..\..\..\ble-mesh-profile\sources\stack\services\timers;..\..\..\..\ble-mesh-profile\sources\stack\services\utils;..\..\..\..\ble-mesh-profile\sources\stack\transports;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\provisioning;..\..\..\..\ble-profiles\sources\services;..\..\..\..\ble-profiles\sources\profiles\include;..\..\..\..\ble-profiles\sources\profiles;..\..\..\..\ble-host\include;..\..\..\..\ble-host\sources\sec\common;..\..\..\..\ble-host\sources\stack\att;..\..\..\..\ble-host\sources\stack\cfg;..\..\..\..\ble-host\sources\stack\dm;..\..\..\..\ble-host\sources\stack\hci;..\..\..\..\ble-host\sources\stack\l2c;..\..\..\..\ble-host\sources\stack\smp;..\..\..\..\thirdparty\uecc;..\..\..\..\ble-host\sources\hci\exactle;..\..\..\..\controller\include\common;..\..\..\..\controller\include\ble;..\..\..\..\controller\sources\ble\include;..\..\..\..\wsf\include;..\..\..\..\platform\include;..\..\..\..\platform\nordic\include;..\..\..\..\wsf\include;..\..\..\..\platform\include
  asm define: __STACK_SIZE=1792 __HEAP_SIZE=0
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group ble-mesh-model
    ../../../../ble-mesh-model/sources/models/htcl/: mesh_ht_cl_main.c
    ../../../../ble-mesh-model/sources/models/htsr/: mesh_ht_sr_main.c mesh_ht_sr_states.c
    ../../../../ble-mesh-model/sources/models/bindings/: mmdl_bindings_main.c
    ../../../../ble-mesh-model/sources/models/common/: mmdl_common_main.c
    ../../../../ble-mesh-model/sources/models/genbatterycl/: mmdl_gen_battery_cl_main.c
    ../../../../ble-mesh-model/sources/models/genbatterysr/: mmdl_gen_battery_sr_main.c
    ../../../../ble-mesh-model/sources/models/gendefaulttransitioncl/: mmdl_gen_default_trans_cl_main.c
    ../../../../ble-mesh-model/sources/models/gendefaulttransitionsr/: mmdl_gen_default_trans_sr_main.c
    ../../../../ble-mesh-model/sources/models/genlevelcl/: mmdl_gen_level_cl_main.c
    ../../../../ble-mesh-model/sources/models/genlevelsr/: mmdl_gen_level_sr_main.c
    ../../../../ble-mesh-model/sources/models/genonoffcl/: mmdl_gen_onoff_cl_main.c
    ../../../../ble-mesh-model/sources/models/genonoffsr/: mmdl_gen_onoff_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelcl/: mmdl_gen_powerlevel_cl_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelsr/: mmdl_gen_powerlevel_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelsetupsr/: mmdl_gen_powerlevelsetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffcl/: mmdl_gen_powonoff_cl_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffsr/: mmdl_gen_powonoff_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffsetupsr/: mmdl_gen_powonoffsetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslcl/: mmdl_light_hsl_cl_main.c
    ../../../../ble-mesh-model/sources/models/lighthslhuesr/: mmdl_light_hsl_hue_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslsatsr/: mmdl_light_hsl_sat_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslsr/: mmdl_light_hsl_setup_sr.c mmdl_light_hsl_sr_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesscl/: mmdl_lightlightness_cl_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesssr/: mmdl_lightlightness_sr_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesssetupsr/: mmdl_lightlightnesssetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/scenecl/: mmdl_scene_cl_main.c
    ../../../../ble-mesh-model/sources/models/scenesr/: mmdl_scene_setup_sr.c mmdl_scene_sr_main.c
    ../../../../ble-mesh-model/sources/models/schedulercl/: mmdl_scheduler_cl_main.c
    ../../../../ble-mesh-model/sources/models/schedulersr/: mmdl_scheduler_setup_sr.c mmdl_scheduler_sr_main.c
    ../../../../ble-mesh-model/sources/models/timecl/: mmdl_time_cl_main.c
    ../../../../ble-mesh-model/sources/models/timesr/: mmdl_time_sr_main.c mmdl_timesetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/vendortestcl/: mmdl_vendor_test_cl_main.c
  group ble-mesh-profile
    ../../../../ble-mesh-profile/sources/bearer/adv/: adv_bearer.c
    ../../../../ble-mesh-profile/sources/stack/cfg/: cfg_mesh_stack.c
    ../../../../ble-mesh-profile/sources/bearer/gatt/: gatt_bearer_cl.c gatt_bearer_sr.c
    ../../../../ble-mesh-profile/sources/stack/access/: mesh_access_main.c mesh_access_period_pub.c
    ../../../../ble-mesh-profile/sources/stack/bearer/: mesh_adv_bearer.c mesh_bearer.c mesh_gatt_bearer.c
    ../../../../ble-mesh-profile/sources/stack/api/: mesh_api.c mesh_cfg_mdl_cl_api.c mesh_cfg_mdl_cl_main.c mesh_cfg_mdl_main.c mesh_cfg_mdl_messages.c mesh_cfg_mdl_opcodes.c mesh_cfg_mdl_sr_api.c mesh_cfg_mdl_sr_app_key.c mesh_cfg_mdl_sr_app_net_key.c mesh_cfg_mdl_sr_main.c mesh_cfg_mdl_sr_pub_subscr.c
    ../../../../ble-mesh-profile/sources/stack/friend/: mesh_friend_act.c mesh_friend_data.c mesh_friend_main.c mesh_friend_queue.c mesh_friend_sm.c
    ../../../../ble-mesh-profile/sources/stack/local_config/: mesh_local_config.c
    ../../../../ble-mesh-profile/sources/stack/transports/: mesh_lower_transport.c mesh_replay_protection.c mesh_sar_rx.c mesh_sar_rx_history.c mesh_sar_tx.c mesh_upper_transport.c mesh_upper_transport_heartbeat.c
    ../../../../ble-mesh-profile/sources/stack/lpn/: mesh_lpn_act.c mesh_lpn_main.c mesh_lpn_sm.c
    ../../../../ble-mesh-profile/sources/stack/network/: mesh_network_beacon.c mesh_network_cache.c mesh_network_if.c mesh_network_main.c mesh_network_mgmt.c
    ../../../../ble-mesh-profile/sources/stack/proxy/: mesh_proxy_cl.c mesh_proxy_main.c mesh_proxy_sr.c
    ../../../../ble-mesh-profile/sources/provisioning/: mesh_prv_beacon.c mesh_prv_br_main.c mesh_prv_cl_act.c mesh_prv_cl_main.c mesh_prv_cl_sm.c mesh_prv_common.c mesh_prv_sr_act.c mesh_prv_sr_main.c mesh_prv_sr_sm.c
    ../../../../ble-mesh-profile/sources/stack/security/: mesh_security_crypto_beacon.c mesh_security_crypto_nwk.c mesh_security_crypto_utr.c mesh_security_deriv.c mesh_security_main.c mesh_security_toolbox.c
    ../../../../ble-mesh-profile/sources/stack/seq_manager/: mesh_seq_manager.c
    ../../../../ble-mesh-profile/sources/stack/services/utils/: mesh_utils.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprvc/: mprvc_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprvs/: mprvs_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprxc/: mprxc_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprxs/: mprxs_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/services/: svc_mprvs.c svc_mprxs.c
  group platform-nordic
    ../../../../platform/nordic/build/: system_armcc_nrf52840.c
  group thirdparty
    ../../../../thirdparty/nordic-bsp/modules/nrfx/mdk/: arm_startup_nrf52840.s
    ../../../../thirdparty/nordic-bsp/external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
    ../../../../thirdparty/nordic-bsp/modules/nrfx/hal/: nrf_ecb.c
  group wsf
    ../../../../wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ../../../../wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_cs.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
