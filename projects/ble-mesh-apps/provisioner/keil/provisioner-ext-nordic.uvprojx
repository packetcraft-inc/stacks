# Keil uVision project provisioner-ext-nordic.uvprojx, settings and files
target provisioner-nordic (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: provisioner-nordic-obj +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: AUDIO_CAPE=0 HCI_TX_DATA_TAILROOM=4 INIT_PERIPHERAL WSF_MS_PER_TICK=1 WSF_BUF_STATS=1 WSF_CS_STATS=1 TERMINAL_MAX_COMMAND_LEN=180 WSF_ASSERT_ENABLED=1 NRF52840_XXAA UART_BAUD=1000000 SEC_ECC_CFG=SEC_ECC_CFG_UECC BT_VER=9 SEC_CCM_CFG=SEC_CCM_CFG_PLATFORM BB_CLK_RATE_HZ=1000000 UART_DEFAULT_CONFIG_HWFC=1 LL_VER=LL_VER_BT_CORE_SPEC_5_0 WSF_PRINTF_MAX_LEN=256 INIT_CENTRAL CHCI_TR_UART=1 __LINT__=0 BOARD_PCA10056 WSF_MAX_HANDLERS=32 QSPI_ENABLED=1 INIT_ENCRYPTED TERMINAL_MAX_ARGC=17 USE_EXACTLE=1
  c misc: --diag_suppress=1296,550,188
  c include: ..\..\..\..\ble-mesh-model\include;..\..\..\..\ble-mesh-model\include\app;..\..\..\..\ble-mesh-model\sources\apps;..\..\..\..\ble-mesh-model\sources\apps\app;..\..\..\..\ble-mesh-model\sources\apps\provisioner;..\..\..\..\ble-profiles\include\app;..\..\..\..\ble-profiles\sources\apps;..\..\..\..\ble-profiles\sources\apps\app;..\..\..\..\ble-mesh-model\include;..\..\..\..\ble-mesh-model\sources\models\include;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\bearer\adv;..\..\..\..\ble-mesh-profile\sources\bearer\gatt;..\..\..\..\ble-mesh-profile\sources\ble-profiles\profiles;..\..\..\..\ble-mesh-profile\sources\ble-profiles\services;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\stack\cfg;..\..\..\..\ble-mesh-profile\sources\stack\access;..\..\..\..\ble-mesh-profile\sources\stack\api;..\..\..\..\ble-mesh-profile\sources\stack\bearer;..\..\..\..\ble-mesh-profile\sources\stack\friend;..\..\..\..\ble-mesh-profile\sources\stack\include;..\..\..\..\ble-mesh-profile\sources\stack\local_config;..\..\..\..\ble-mesh-profile\sources\stack\lpn;..\..\..\..\ble-mesh-profile\sources\stack\network;..\..\..\..\ble-mesh-profile\sources\stack\security;..\..\..\..\ble-mesh-profile\sources\stack\seq_manager;..\..\..\..\ble-mesh-profile\sources\stack\services\timers;..\..\..\..\ble-mesh-profile\sources\stack\services\utils;..\..\..\..\ble-mesh-profile\sources\stack\transports;..\..\..\..\ble-mesh-profile\include;..\..\..\..\ble-mesh-profile\sources\provisioning;..\..\..\..\ble-profiles\sources\services;..\..\..\..\ble-profiles\sources\profiles\include;..\..\..\..\ble-profiles\sources\profiles;..\..\..\..\ble-host\include;..\..\..\..\ble-host\sources\sec\common;..\..\..\..\ble-host\sources\stack\att;..\..\..\..\ble-host\sources\stack\cfg;..\..\..\..\ble-host\sources\stack\dm;..\..\..\..\ble-host\sources\stack\hci;..\..\..\..\ble-host\sources\stack\l2c;..\..\..\..\ble-host\sources\stack\smp;..\..\..\..\ble-host\sources\sec\common;..\..\..\..\platform\include;..\..\..\..\ble-host\sources\hci\exactle;..\..\..\..\controller\include\common;..\..\..\..\controller\include\ble;..\..\..\..\controller\sources\ble\include;..\..\..\..\thirdparty\uecc;..\..\..\..\wsf\include;..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\mdk;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\hal;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers\include;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\soc;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\crypto;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\thirdparty\nordic-bsp\external\nrf_cc310\include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates\nRF52840;..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\components\device;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\hal;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\bsp;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\wsf\include;..\..\..\..\platform\include
  asm define: __STACK_SIZE=1792 __HEAP_SIZE=0
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group ble-host
    ../../../../ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../ble-host/sources/hci/exactle/: hci_cmd.c hci_cmd_ae.c hci_cmd_enc.c hci_cmd_master.c hci_cmd_master_ae.c hci_cmd_phy.c hci_core_ps.c hci_evt.c hci_vs.c hci_vs_ae.c
    ../../../../ble-host/sources/hci/common/: hci_core.c hci_tr.c
    ../../../../ble-host/sources/stack/hci/: hci_main.c
    ../../../../ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../../../../ble-host/sources/sec/pal/: sec_ccm.c
    ../../../../ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
  group ble-mesh-model
    ../../../../ble-mesh-model/sources/apps/app/: app_bearer.c app_mesh_cfg_mdl_cl_terminal.c app_mesh_main.c app_mesh_terminal.c app_mmdl_terminal.c app_proxy.c
    ../../../../ble-mesh-model/sources/models/htcl/: mesh_ht_cl_main.c
    ../../../../ble-mesh-model/sources/models/htsr/: mesh_ht_sr_main.c mesh_ht_sr_states.c
    ../../../../ble-mesh-model/sources/models/bindings/: mmdl_bindings_main.c
    ../../../../ble-mesh-model/sources/models/common/: mmdl_common_main.c
    ../../../../ble-mesh-model/sources/models/genbatterycl/: mmdl_gen_battery_cl_main.c
    ../../../../ble-mesh-model/sources/models/genbatterysr/: mmdl_gen_battery_sr_main.c
    ../../../../ble-mesh-model/sources/models/gendefaulttransitioncl/: mmdl_gen_default_trans_cl_main.c
    ../../../../ble-mesh-model/sources/models/gendefaulttransitionsr/: mmdl_gen_default_trans_sr_main.c
    ../../../../ble-mesh-model/sources/models/genlevelcl/: mmdl_gen_level_cl_main.c
    ../../../../ble-mesh-model/sources/models/genlevelsr/: mmdl_gen_level_sr_main.c
    ../../../../ble-mesh-model/sources/models/genonoffcl/: mmdl_gen_onoff_cl_main.c
    ../../../../ble-mesh-model/sources/models/genonoffsr/: mmdl_gen_onoff_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelcl/: mmdl_gen_powerlevel_cl_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelsr/: mmdl_gen_powerlevel_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowerlevelsetupsr/: mmdl_gen_powerlevelsetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffcl/: mmdl_gen_powonoff_cl_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffsr/: mmdl_gen_powonoff_sr_main.c
    ../../../../ble-mesh-model/sources/models/genpowonoffsetupsr/: mmdl_gen_powonoffsetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslcl/: mmdl_light_hsl_cl_main.c
    ../../../../ble-mesh-model/sources/models/lighthslhuesr/: mmdl_light_hsl_hue_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslsatsr/: mmdl_light_hsl_sat_sr_main.c
    ../../../../ble-mesh-model/sources/models/lighthslsr/: mmdl_light_hsl_setup_sr.c mmdl_light_hsl_sr_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesscl/: mmdl_lightlightness_cl_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesssr/: mmdl_lightlightness_sr_main.c
    ../../../../ble-mesh-model/sources/models/lightlightnesssetupsr/: mmdl_lightlightnesssetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/scenecl/: mmdl_scene_cl_main.c
    ../../../../ble-mesh-model/sources/models/scenesr/: mmdl_scene_setup_sr.c mmdl_scene_sr_main.c
    ../../../../ble-mesh-model/sources/models/schedulercl/: mmdl_scheduler_cl_main.c
    ../../../../ble-mesh-model/sources/models/schedulersr/: mmdl_scheduler_setup_sr.c mmdl_scheduler_sr_main.c
    ../../../../ble-mesh-model/sources/models/timecl/: mmdl_time_cl_main.c
    ../../../../ble-mesh-model/sources/models/timesr/: mmdl_time_sr_main.c mmdl_timesetup_sr_main.c
    ../../../../ble-mesh-model/sources/models/vendortestcl/: mmdl_vendor_test_cl_main.c
    ../../../../ble-mesh-model/sources/apps/provisioner/: provisioner_config.c provisioner_main.c provisioner_menu.c provisioner_mmdl_handler.c provisioner_terminal.c
  group ble-mesh-profile
    ../../../../ble-mesh-profile/sources/bearer/adv/: adv_bearer.c
    ../../../../ble-mesh-profile/sources/stack/cfg/: cfg_mesh_stack.c
    ../../../../ble-mesh-profile/sources/bearer/gatt/: gatt_bearer_cl.c gatt_bearer_sr.c
    ../../../../ble-mesh-profile/sources/stack/access/: mesh_access_main.c mesh_access_period_pub.c
    ../../../../ble-mesh-profile/sources/stack/bearer/: mesh_adv_bearer.c mesh_bearer.c mesh_gatt_bearer.c
    ../../../../ble-mesh-profile/sources/stack/api/: mesh_api.c mesh_cfg_mdl_cl_api.c mesh_cfg_mdl_cl_main.c mesh_cfg_mdl_main.c mesh_cfg_mdl_messages.c mesh_cfg_mdl_opcodes.c mesh_cfg_mdl_sr_api.c mesh_cfg_mdl_sr_app_key.c mesh_cfg_mdl_sr_app_net_key.c mesh_cfg_mdl_sr_main.c mesh_cfg_mdl_sr_pub_subscr.c
    ../../../../ble-mesh-profile/sources/stack/friend/: mesh_friend_act.c mesh_friend_data.c mesh_friend_main.c mesh_friend_queue.c mesh_friend_sm.c
    ../../../../ble-mesh-profile/sources/stack/local_config/: mesh_local_config.c
    ../../../../ble-mesh-profile/sources/stack/transports/: mesh_lower_transport.c mesh_replay_protection.c mesh_sar_rx.c mesh_sar_rx_history.c mesh_sar_tx.c mesh_upper_transport.c mesh_upper_transport_heartbeat.c
    ../../../../ble-mesh-profile/sources/stack/lpn/: mesh_lpn_act.c mesh_lpn_main.c mesh_lpn_sm.c
    ../../../../ble-mesh-profile/sources/stack/network/: mesh_network_beacon.c mesh_network_cache.c mesh_network_if.c mesh_network_main.c mesh_network_mgmt.c
    ../../../../ble-mesh-profile/sources/stack/proxy/: mesh_proxy_cl.c mesh_proxy_main.c mesh_proxy_sr.c
    ../../../../ble-mesh-profile/sources/provisioning/: mesh_prv_beacon.c mesh_prv_br_main.c mesh_prv_cl_act.c mesh_prv_cl_main.c mesh_prv_cl_sm.c mesh_prv_common.c mesh_prv_sr_act.c mesh_prv_sr_main.c mesh_prv_sr_sm.c
    ../../../../ble-mesh-profile/sources/stack/security/: mesh_security_crypto_beacon.c mesh_security_crypto_nwk.c mesh_security_crypto_utr.c mesh_security_deriv.c mesh_security_main.c mesh_security_toolbox.c
    ../../../../ble-mesh-profile/sources/stack/seq_manager/: mesh_seq_manager.c
    ../../../../ble-mesh-profile/sources/stack/services/utils/: mesh_utils.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprvc/: mprvc_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprvs/: mprvs_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprxc/: mprxc_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/profiles/mprxs/: mprxs_main.c
    ../../../../ble-mesh-profile/sources/ble-profiles/services/: svc_mprvs.c svc_mprxs.c
  group ble-profiles
    ../../../../ble-profiles/sources/profiles/anpc/: anpc_main.c
    ../../../../ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ../../../../ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../ble-profiles/sources/profiles/blpc/: blpc_main.c
    ../../../../ble-profiles/sources/profiles/blps/: blps_main.c
    ../../../../ble-profiles/sources/profiles/cpp/: cpps_main.c
    ../../../../ble-profiles/sources/profiles/cscp/: cscps_main.c
    ../../../../ble-profiles/sources/profiles/dis/: dis_main.c
    ../../../../ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ../../../../ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../ble-profiles/sources/profiles/glpc/: glpc_main.c
    ../../../../ble-profiles/sources/profiles/glps/: glps_db.c glps_main.c
    ../../../../ble-profiles/sources/profiles/sensor/: gyro_main.c temp_main.c
    ../../../../ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ../../../../ble-profiles/sources/profiles/hrps/: hrps_main.c
    ../../../../ble-profiles/sources/profiles/htpc/: htpc_main.c
    ../../../../ble-profiles/sources/profiles/htps/: htps_main.c
    ../../../../ble-profiles/sources/profiles/paspc/: paspc_main.c
    ../../../../ble-profiles/sources/profiles/plxpc/: plxpc_main.c
    ../../../../ble-profiles/sources/profiles/plxps/: plxps_db.c plxps_main.c
    ../../../../ble-profiles/sources/profiles/rscp/: rscps_main.c
    ../../../../ble-profiles/sources/profiles/scpps/: scpps_main.c
    ../../../../ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../ble-profiles/sources/profiles/tipc/: tipc_main.c
    ../../../../ble-profiles/sources/profiles/udsc/: udsc_main.c
    ../../../../ble-profiles/sources/profiles/uribeacon/: uricfg_main.c
    ../../../../ble-profiles/sources/profiles/wdxc/: wdxc_ft.c wdxc_main.c wdxc_stream.c
    ../../../../ble-profiles/sources/profiles/wdxs/: wdxs_au.c wdxs_dc.c wdxs_ft.c wdxs_main.c wdxs_phy.c wdxs_stream.c
    ../../../../ble-profiles/sources/profiles/wpc/: wpc_main.c
    ../../../../ble-profiles/sources/profiles/wspc/: wspc_main.c
    ../../../../ble-profiles/sources/profiles/wsps/: wsps_main.c
  group controller
    ../../../../controller/sources/ble/bb/: bb_ble_adv_master.c bb_ble_adv_master_ae.c bb_ble_adv_slave.c bb_ble_adv_slave_ae.c bb_ble_conn.c bb_ble_conn_master.c bb_ble_conn_slave.c bb_ble_main.c bb_ble_pdufilt.c bb_ble_periodiclist.c bb_ble_reslist.c bb_ble_test.c bb_ble_whitelist.c
    ../../../../controller/sources/common/bb/: bb_main.c
    ../../../../controller/sources/common/chci/: chci_tr.c
    ../../../../controller/sources/ble/init/: init.c init_ctr.c
    ../../../../controller/sources/ble/lctr/: lctr_act_adv_master.c lctr_act_adv_master_ae.c lctr_act_adv_slave.c lctr_act_adv_slave_ae.c lctr_act_conn.c lctr_act_conn_master.c lctr_act_conn_master_ae.c lctr_act_conn_past.c lctr_act_enc.c lctr_act_enc_master.c lctr_act_init_master.c lctr_act_init_master_ae.c lctr_act_phy.c lctr_isr_adv_master.c lctr_isr_adv_master_ae.c lctr_isr_adv_slave.c lctr_isr_adv_slave_ae.c lctr_isr_conn.c lctr_isr_conn_master.c lctr_isr_conn_slave.c lctr_isr_init_master.c lctr_isr_init_master_ae.c lctr_main.c lctr_main_adv_master.c lctr_main_adv_master_ae.c lctr_main_adv_slave.c lctr_main_adv_slave_ae.c lctr_main_conn.c lctr_main_conn_cs2.c lctr_main_conn_data.c lctr_main_conn_master.c lctr_main_conn_slave.c lctr_main_enc_master.c lctr_main_enc_slave.c lctr_main_init_master.c lctr_main_init_master_ae.c lctr_main_master_phy.c lctr_main_past.c lctr_main_priv.c lctr_main_sc.c lctr_main_slave_phy.c lctr_pdu_adv_master_ae.c lctr_pdu_adv_slave.c lctr_pdu_adv_slave_ae.c lctr_pdu_conn.c lctr_pdu_enc.c lctr_sm_adv_master.c lctr_sm_adv_master_ae.c lctr_sm_adv_slave.c lctr_sm_adv_slave_ae.c lctr_sm_conn_master.c lctr_sm_conn_slave.c lctr_sm_init_master.c lctr_sm_init_master_ae.c lctr_sm_llcp_conn.c lctr_sm_llcp_conn_master.c lctr_sm_llcp_conn_slave.c lctr_sm_llcp_enc_master.c lctr_sm_llcp_enc_slave.c lctr_sm_llcp_master_phy.c lctr_sm_llcp_slave_phy.c
    ../../../../controller/sources/ble/lhci/: lhci_cmd.c lhci_cmd_adv_master.c lhci_cmd_adv_master_ae.c lhci_cmd_adv_priv.c lhci_cmd_adv_slave.c lhci_cmd_adv_slave_ae.c lhci_cmd_conn.c lhci_cmd_conn_master.c lhci_cmd_conn_master_ae.c lhci_cmd_conn_priv.c lhci_cmd_enc_master.c lhci_cmd_enc_slave.c lhci_cmd_past.c lhci_cmd_phy.c lhci_cmd_sc.c lhci_cmd_vs.c lhci_cmd_vs_adv_master.c lhci_cmd_vs_adv_master_ae.c lhci_cmd_vs_adv_slave.c lhci_cmd_vs_adv_slave_ae.c lhci_cmd_vs_conn.c lhci_cmd_vs_conn_master.c lhci_cmd_vs_enc_slave.c lhci_cmd_vs_ext.c lhci_cmd_vs_sc.c lhci_evt.c lhci_evt_adv_master.c lhci_evt_adv_master_ae.c lhci_evt_adv_slave.c lhci_evt_adv_slave_ae.c lhci_evt_conn.c lhci_evt_conn_cs2.c lhci_evt_conn_master.c lhci_evt_conn_priv.c lhci_evt_enc_master.c lhci_evt_enc_slave.c lhci_evt_phy.c lhci_evt_sc.c lhci_evt_vs.c lhci_init.c lhci_init_adv_master.c lhci_init_adv_master_ae.c lhci_init_adv_priv.c lhci_init_adv_slave.c lhci_init_adv_slave_ae.c lhci_init_conn.c lhci_init_conn_cs2.c lhci_init_conn_master.c lhci_init_conn_master_ae.c lhci_init_conn_priv.c lhci_init_enc_master.c lhci_init_enc_slave.c lhci_init_past.c lhci_init_phy.c lhci_init_sc.c lhci_main.c
    ../../../../controller/sources/ble/ll/: ll_init.c ll_init_adv_master.c ll_init_adv_master_ae.c ll_init_adv_slave.c ll_init_adv_slave_ae.c ll_init_conn_cs2.c ll_init_conn_master.c ll_init_conn_slave.c ll_init_enc_master.c ll_init_enc_slave.c ll_init_init_master.c ll_init_init_master_ae.c ll_init_master_phy.c ll_init_past.c ll_init_priv.c ll_init_sc.c ll_init_slave_phy.c ll_main.c ll_main_adv_master.c ll_main_adv_master_ae.c ll_main_adv_slave.c ll_main_adv_slave_ae.c ll_main_conn.c ll_main_conn_master.c ll_main_conn_master_ae.c ll_main_conn_slave.c ll_main_dtm.c ll_main_enc_master.c ll_main_enc_slave.c ll_main_past.c ll_main_phy.c ll_main_priv.c ll_main_sc.c ll_math.c
    ../../../../controller/sources/ble/lmgr/: lmgr_events.c lmgr_main.c lmgr_main_adv_master_ae.c lmgr_main_adv_slave_ae.c lmgr_main_conn.c lmgr_main_master.c lmgr_main_priv.c lmgr_main_sc.c lmgr_main_slave.c
    ../../../../controller/sources/ble/sch/: sch_ble.c sch_rm.c
    ../../../../controller/sources/common/sch/: sch_list.c sch_main.c
  group platform-external
    ../../../../platform/external/sources/audio_amp/: maxim9867.c
    ../../../../platform/external/sources/io_exp/: pca9557.c
  group platform-nordic
    ../../../../platform/nordic/sources/: pal_bb.c pal_bb_ble.c pal_bb_ble_rf.c pal_bb_ble_tester.c pal_btn.c pal_cfg.c pal_crypto.c pal_led.c pal_nvm.c pal_rtc.c pal_sys.c pal_timer.c pal_twi.c pal_uart.c
    ../../../../platform/nordic/build/: system_armcc_nrf52840.c
  group projects
    ../../../../projects/ble-mesh-apps/provisioner/: main.c stack_provisioner.c
  group thirdparty
    ../../../../thirdparty/nordic-bsp/modules/nrfx/mdk/: arm_startup_nrf52840.s
    ../../../../thirdparty/nordic-bsp/external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
    ../../../../thirdparty/nordic-bsp/modules/nrfx/hal/: nrf_ecb.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/: nrfx_qspi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    ../../../../thirdparty/uecc/: uECC.c uECC_ll.c
  group wsf
    ../../../../wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ../../../../wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_cs.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
