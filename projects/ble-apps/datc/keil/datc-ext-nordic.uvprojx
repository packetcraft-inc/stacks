# Keil uVision project datc-ext-nordic.uvprojx, settings and files
target datc-nordic (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: datc-nordic-obj +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: WDXC_INCLUDED=1 WSF_PRINTF_MAX_LEN=128 BOARD_PCA10056 NRF52840_XXAA UART_BAUD=1000000 WSF_BUF_STATS=1 BB_CLK_RATE_HZ=1000000 CHCI_TR_UART=1 BT_VER=10 INIT_ENCRYPTED AUDIO_CAPE=0 QSPI_ENABLED=1 UART_DEFAULT_CONFIG_HWFC=1 HCI_TX_DATA_TAILROOM=4 INIT_CENTRAL WSF_TRACE_ENABLED=1 __LINT__=0 CS50_INCLUDED=TRUE WSF_CS_STATS=1 USE_EXACTLE=1
  c misc: --diag_suppress=1296,550,188
  c include: ..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\mdk;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\hal;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers\include;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\soc;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\crypto;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\thirdparty\nordic-bsp\external\nrf_cc310\include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates\nRF52840;..\..\..\..\ble-host\sources\hci\exactle;..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\components\device;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\hal;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\bsp;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\ble-host\include;..\..\..\..\ble-host\sources\stack\cfg;..\..\..\..\ble-host\sources\stack\dm;..\..\..\..\ble-profiles\include\app;..\..\..\..\ble-profiles\sources\apps;..\..\..\..\ble-profiles\sources\apps\app;..\..\..\..\ble-profiles\sources\profiles;..\..\..\..\ble-profiles\sources\profiles\include;..\..\..\..\ble-profiles\sources\services;..\..\..\..\controller\include\ble;..\..\..\..\controller\include\common;..\..\..\..\wsf\include;..\..\..\..\wsf\include;..\..\..\..\platform\include;..\..\..\..\controller\include\common;..\..\..\..\controller\include\ble;..\..\..\..\controller\sources\ble\include;..\..\..\..\thirdparty\uecc;..\..\..\..\wsf\include;..\..\..\..\platform\include;..\..\..\..\ble-host\include;..\..\..\..\ble-host\sources\stack\att;..\..\..\..\ble-host\sources\stack\cfg;..\..\..\..\ble-host\sources\stack\dm;..\..\..\..\ble-host\sources\stack\hci;..\..\..\..\ble-host\sources\stack\l2c;..\..\..\..\ble-host\sources\stack\smp;..\..\..\..\platform\include;..\..\..\..\ble-profiles\sources\profiles\include;..\..\..\..\ble-profiles\sources\profiles;..\..\..\..\ble-host\sources\hci\exactle;..\..\..\..\ble-profiles\sources\services;..\..\..\..\ble-profiles\include\app;..\..\..\..\ble-profiles\sources\apps\app;..\..\..\..\controller\include\ble;..\..\..\..\controller\include\common;..\..\..\..\wsf\include
  asm define: __STACK_SIZE=1792 __HEAP_SIZE=0
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group ble-host
    ../../../../ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ../../../../ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../ble-host/sources/hci/exactle/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_enc.c hci_cmd_master.c hci_cmd_master_ae.c hci_cmd_past.c hci_cmd_phy.c hci_core_ps.c hci_evt.c hci_vs.c hci_vs_ae.c
    ../../../../ble-host/sources/hci/common/: hci_core.c hci_tr.c
    ../../../../ble-host/sources/stack/hci/: hci_main.c
    ../../../../ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../ble-host/sources/sec/common/: sec_aes.c sec_cmac_hci.c sec_ecc_hci.c sec_main.c
    ../../../../ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
  group ble-profiles
    ../../../../ble-profiles/sources/profiles/anpc/: anpc_main.c
    ../../../../ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ../../../../ble-profiles/sources/profiles/atpc/: atpc_main.c
    ../../../../ble-profiles/sources/profiles/atps/: atps_main.c
    ../../../../ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../ble-profiles/sources/profiles/blpc/: blpc_main.c
    ../../../../ble-profiles/sources/profiles/blps/: blps_main.c
    ../../../../ble-profiles/sources/profiles/cpp/: cpps_main.c
    ../../../../ble-profiles/sources/profiles/cscp/: cscps_main.c
    ../../../../ble-profiles/sources/apps/datc/: datc_main.c
    ../../../../ble-profiles/sources/profiles/dis/: dis_main.c
    ../../../../ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ../../../../ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../ble-profiles/sources/profiles/glpc/: glpc_main.c
    ../../../../ble-profiles/sources/profiles/glps/: glps_db.c glps_main.c
    ../../../../ble-profiles/sources/profiles/sensor/: gyro_main.c temp_main.c
    ../../../../ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ../../../../ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ../../../../ble-profiles/sources/profiles/hrps/: hrps_main.c
    ../../../../ble-profiles/sources/profiles/htpc/: htpc_main.c
    ../../../../ble-profiles/sources/profiles/htps/: htps_main.c
    ../../../../ble-profiles/sources/profiles/paspc/: paspc_main.c
    ../../../../ble-profiles/sources/profiles/plxpc/: plxpc_main.c
    ../../../../ble-profiles/sources/profiles/plxps/: plxps_db.c plxps_main.c
    ../../../../ble-profiles/sources/profiles/rscp/: rscps_main.c
    ../../../../ble-profiles/sources/profiles/scpps/: scpps_main.c
    ../../../../ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../ble-profiles/sources/profiles/tipc/: tipc_main.c
    ../../../../ble-profiles/sources/profiles/udsc/: udsc_main.c
    ../../../../ble-profiles/sources/profiles/uribeacon/: uricfg_main.c
    ../../../../ble-profiles/sources/profiles/wdxc/: wdxc_ft.c wdxc_main.c wdxc_stream.c
    ../../../../ble-profiles/sources/profiles/wdxs/: wdxs_au.c wdxs_dc.c wdxs_ft.c wdxs_main.c wdxs_phy.c wdxs_stream.c
    ../../../../ble-profiles/sources/profiles/wpc/: wpc_main.c
    ../../../../ble-profiles/sources/profiles/wspc/: wspc_main.c
    ../../../../ble-profiles/sources/profiles/wsps/: wsps_main.c
  group controller
    ../../../../controller/sources/ble/bb/: bb_ble_adv_master.c bb_ble_adv_master_ae.c bb_ble_adv_slave.c bb_ble_adv_slave_ae.c bb_ble_conn.c bb_ble_conn_master.c bb_ble_conn_slave.c bb_ble_main.c bb_ble_pdufilt.c bb_ble_periodiclist.c bb_ble_reslist.c bb_ble_test.c bb_ble_whitelist.c
    ../../../../controller/sources/common/bb/: bb_main.c
    ../../../../controller/sources/common/chci/: chci_tr.c
    ../../../../controller/sources/ble/init/: init.c init_ctr.c
    ../../../../controller/sources/ble/lctr/: lctr_act_adv_master.c lctr_act_adv_master_ae.c lctr_act_adv_slave.c lctr_act_adv_slave_ae.c lctr_act_conn.c lctr_act_conn_master.c lctr_act_conn_master_ae.c lctr_act_conn_past.c lctr_act_enc.c lctr_act_enc_master.c lctr_act_init_master.c lctr_act_init_master_ae.c lctr_act_phy.c lctr_isr_adv_master.c lctr_isr_adv_master_ae.c lctr_isr_adv_slave.c lctr_isr_adv_slave_ae.c lctr_isr_conn.c lctr_isr_conn_master.c lctr_isr_conn_slave.c lctr_isr_init_master.c lctr_isr_init_master_ae.c lctr_main.c lctr_main_adv_master.c lctr_main_adv_master_ae.c lctr_main_adv_slave.c lctr_main_adv_slave_ae.c lctr_main_conn.c lctr_main_conn_cs2.c lctr_main_conn_data.c lctr_main_conn_master.c lctr_main_conn_slave.c lctr_main_enc_master.c lctr_main_enc_slave.c lctr_main_init_master.c lctr_main_init_master_ae.c lctr_main_master_phy.c lctr_main_past.c lctr_main_priv.c lctr_main_sc.c lctr_main_slave_phy.c lctr_pdu_adv_master_ae.c lctr_pdu_adv_slave.c lctr_pdu_adv_slave_ae.c lctr_pdu_conn.c lctr_pdu_enc.c lctr_sm_adv_master.c lctr_sm_adv_master_ae.c lctr_sm_adv_slave.c lctr_sm_adv_slave_ae.c lctr_sm_conn_master.c lctr_sm_conn_slave.c lctr_sm_init_master.c lctr_sm_init_master_ae.c lctr_sm_llcp_conn.c lctr_sm_llcp_conn_master.c lctr_sm_llcp_conn_slave.c lctr_sm_llcp_enc_master.c lctr_sm_llcp_enc_slave.c lctr_sm_llcp_master_phy.c lctr_sm_llcp_slave_phy.c
    ../../../../controller/sources/ble/lhci/: lhci_cmd.c lhci_cmd_adv_master.c lhci_cmd_adv_master_ae.c lhci_cmd_adv_priv.c lhci_cmd_adv_slave.c lhci_cmd_adv_slave_ae.c lhci_cmd_conn.c lhci_cmd_conn_master.c lhci_cmd_conn_master_ae.c lhci_cmd_conn_priv.c lhci_cmd_enc_master.c lhci_cmd_enc_slave.c lhci_cmd_past.c lhci_cmd_phy.c lhci_cmd_sc.c lhci_cmd_vs.c lhci_cmd_vs_adv_master.c lhci_cmd_vs_adv_master_ae.c lhci_cmd_vs_adv_slave.c lhci_cmd_vs_adv_slave_ae.c lhci_cmd_vs_conn.c lhci_cmd_vs_conn_master.c lhci_cmd_vs_enc_slave.c lhci_cmd_vs_ext.c lhci_cmd_vs_sc.c lhci_evt.c lhci_evt_adv_master.c lhci_evt_adv_master_ae.c lhci_evt_adv_slave.c lhci_evt_adv_slave_ae.c lhci_evt_conn.c lhci_evt_conn_cs2.c lhci_evt_conn_master.c lhci_evt_conn_priv.c lhci_evt_enc_master.c lhci_evt_enc_slave.c lhci_evt_phy.c lhci_evt_sc.c lhci_evt_vs.c lhci_init.c lhci_init_adv_master.c lhci_init_adv_master_ae.c lhci_init_adv_priv.c lhci_init_adv_slave.c lhci_init_adv_slave_ae.c lhci_init_conn.c lhci_init_conn_cs2.c lhci_init_conn_master.c lhci_init_conn_master_ae.c lhci_init_conn_priv.c lhci_init_enc_master.c lhci_init_enc_slave.c lhci_init_past.c lhci_init_phy.c lhci_init_sc.c lhci_main.c
    ../../../../controller/sources/ble/ll/: ll_init.c ll_init_adv_master.c ll_init_adv_master_ae.c ll_init_adv_slave.c ll_init_adv_slave_ae.c ll_init_conn_cs2.c ll_init_conn_master.c ll_init_conn_slave.c ll_init_enc_master.c ll_init_enc_slave.c ll_init_init_master.c ll_init_init_master_ae.c ll_init_master_phy.c ll_init_past.c ll_init_priv.c ll_init_sc.c ll_init_slave_phy.c ll_main.c ll_main_adv_master.c ll_main_adv_master_ae.c ll_main_adv_slave.c ll_main_adv_slave_ae.c ll_main_conn.c ll_main_conn_master.c ll_main_conn_master_ae.c ll_main_conn_slave.c ll_main_dtm.c ll_main_enc_master.c ll_main_enc_slave.c ll_main_past.c ll_main_phy.c ll_main_priv.c ll_main_sc.c ll_math.c
    ../../../../controller/sources/ble/lmgr/: lmgr_events.c lmgr_main.c lmgr_main_adv_master_ae.c lmgr_main_adv_slave_ae.c lmgr_main_conn.c lmgr_main_master.c lmgr_main_priv.c lmgr_main_sc.c lmgr_main_slave.c
    ../../../../controller/sources/ble/sch/: sch_ble.c sch_rm.c
    ../../../../controller/sources/common/sch/: sch_list.c sch_main.c
  group platform-external
    ../../../../platform/external/sources/audio_amp/: maxim9867.c
    ../../../../platform/external/sources/io_exp/: pca9557.c
  group platform-nordic
    ../../../../platform/nordic/sources/: pal_bb.c pal_bb_ble.c pal_bb_ble_rf.c pal_bb_ble_tester.c pal_btn.c pal_cfg.c pal_crypto.c pal_led.c pal_nvm.c pal_rtc.c pal_sys.c pal_timer.c pal_twi.c pal_uart.c
    ../../../../platform/nordic/build/: system_armcc_nrf52840.c
  group projects
    ../../../../projects/ble-apps/datc/: main.c stack_datc.c
  group thirdparty
    ../../../../thirdparty/nordic-bsp/modules/nrfx/mdk/: arm_startup_nrf52840.s
    ../../../../thirdparty/nordic-bsp/external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
    ../../../../thirdparty/nordic-bsp/modules/nrfx/hal/: nrf_ecb.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/: nrfx_qspi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    ../../../../thirdparty/uecc/: uECC_ll.c
  group wsf
    ../../../../wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ../../../../wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_cs.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
