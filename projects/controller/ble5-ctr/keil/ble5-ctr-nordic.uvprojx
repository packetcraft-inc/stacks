# Keil uVision project ble5-ctr-nordic.uvprojx, settings and files
target ble5-ctr-nordic (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ble5-ctr-nordic-obj +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: AUDIO_CAPE=0 HCI_TX_DATA_TAILROOM=4 INIT_PERIPHERAL WSF_BUF_STATS=1 WSF_CS_STATS=1 NRF52840_XXAA UART_BAUD=1000000 SCH_CHECK_LIST_INTEGRITY=1 INIT_BROADCASTER INIT_OBSERVER BT_VER=10 BB_LED_ENA=1 BB_CLK_RATE_HZ=1000000 uECC_ASM=2 UART_DEFAULT_CONFIG_HWFC=1 INIT_CENTRAL CHCI_TR_UART=1 __LINT__=0 BOARD_PCA10056 QSPI_ENABLED=1 INIT_ENCRYPTED USE_EXACTLE=1
  c misc: --diag_suppress=1296,550,188
  c include: ..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\mdk;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\hal;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers\include;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\drivers;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\soc;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\crypto;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\thirdparty\nordic-bsp\external\nrf_cc310\include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\thirdparty\nordic-bsp\modules\nrfx\templates\nRF52840;..\..\..\..\thirdparty\nordic-bsp\components\boards;..\..\..\..\thirdparty\nordic-bsp\components\device;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\hal;..\..\..\..\thirdparty\nordic-bsp\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\thirdparty\nordic-bsp\components\libraries\bsp;..\..\..\..\thirdparty\nordic-bsp\components\libraries\util;..\..\..\..\thirdparty\nordic-bsp\components\toolchain;..\..\..\..\thirdparty\nordic-bsp\components\toolchain\CMSIS\Include;..\..\..\..\platform\nordic\include;..\..\..\..\platform\include;..\..\..\..\thirdparty\uecc;..\..\..\..\controller\include\common;..\..\..\..\controller\include\ble;..\..\..\..\wsf\include;..\..\..\..\wsf\include;..\..\..\..\platform\include;..\..\..\..\controller\include\common;..\..\..\..\controller\include\ble;..\..\..\..\controller\sources\ble\include;..\..\..\..\thirdparty\uecc;..\..\..\..\wsf\include;..\..\..\..\platform\include
  asm define: __STACK_SIZE=1792 __HEAP_SIZE=0
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group controller
    ../../../../controller/sources/ble/bb/: bb_ble_adv_master.c bb_ble_adv_master_ae.c bb_ble_adv_slave.c bb_ble_adv_slave_ae.c bb_ble_conn.c bb_ble_conn_master.c bb_ble_conn_slave.c bb_ble_main.c bb_ble_pdufilt.c bb_ble_periodiclist.c bb_ble_reslist.c bb_ble_test.c bb_ble_whitelist.c
    ../../../../controller/sources/common/bb/: bb_main.c
    ../../../../controller/sources/common/chci/: chci_tr.c
    ../../../../controller/sources/ble/init/: init.c init_ctr.c
    ../../../../controller/sources/ble/lctr/: lctr_act_adv_master.c lctr_act_adv_master_ae.c lctr_act_adv_slave.c lctr_act_adv_slave_ae.c lctr_act_conn.c lctr_act_conn_master.c lctr_act_conn_master_ae.c lctr_act_conn_past.c lctr_act_enc.c lctr_act_enc_master.c lctr_act_init_master.c lctr_act_init_master_ae.c lctr_act_phy.c lctr_isr_adv_master.c lctr_isr_adv_master_ae.c lctr_isr_adv_slave.c lctr_isr_adv_slave_ae.c lctr_isr_conn.c lctr_isr_conn_master.c lctr_isr_conn_slave.c lctr_isr_init_master.c lctr_isr_init_master_ae.c lctr_main.c lctr_main_adv_master.c lctr_main_adv_master_ae.c lctr_main_adv_slave.c lctr_main_adv_slave_ae.c lctr_main_conn.c lctr_main_conn_cs2.c lctr_main_conn_data.c lctr_main_conn_master.c lctr_main_conn_slave.c lctr_main_enc_master.c lctr_main_enc_slave.c lctr_main_init_master.c lctr_main_init_master_ae.c lctr_main_master_phy.c lctr_main_past.c lctr_main_priv.c lctr_main_sc.c lctr_main_slave_phy.c lctr_pdu_adv_master_ae.c lctr_pdu_adv_slave.c lctr_pdu_adv_slave_ae.c lctr_pdu_conn.c lctr_pdu_enc.c lctr_sm_adv_master.c lctr_sm_adv_master_ae.c lctr_sm_adv_slave.c lctr_sm_adv_slave_ae.c lctr_sm_conn_master.c lctr_sm_conn_slave.c lctr_sm_init_master.c lctr_sm_init_master_ae.c lctr_sm_llcp_conn.c lctr_sm_llcp_conn_master.c lctr_sm_llcp_conn_slave.c lctr_sm_llcp_enc_master.c lctr_sm_llcp_enc_slave.c lctr_sm_llcp_master_phy.c lctr_sm_llcp_slave_phy.c
    ../../../../controller/sources/ble/lhci/: lhci_cmd.c lhci_cmd_adv_master.c lhci_cmd_adv_master_ae.c lhci_cmd_adv_priv.c lhci_cmd_adv_slave.c lhci_cmd_adv_slave_ae.c lhci_cmd_conn.c lhci_cmd_conn_master.c lhci_cmd_conn_master_ae.c lhci_cmd_conn_priv.c lhci_cmd_enc_master.c lhci_cmd_enc_slave.c lhci_cmd_past.c lhci_cmd_phy.c lhci_cmd_sc.c lhci_cmd_vs.c lhci_cmd_vs_adv_master.c lhci_cmd_vs_adv_master_ae.c lhci_cmd_vs_adv_slave.c lhci_cmd_vs_adv_slave_ae.c lhci_cmd_vs_conn.c lhci_cmd_vs_conn_master.c lhci_cmd_vs_enc_slave.c lhci_cmd_vs_ext.c lhci_cmd_vs_sc.c lhci_evt.c lhci_evt_adv_master.c lhci_evt_adv_master_ae.c lhci_evt_adv_slave.c lhci_evt_adv_slave_ae.c lhci_evt_conn.c lhci_evt_conn_cs2.c lhci_evt_conn_master.c lhci_evt_conn_priv.c lhci_evt_enc_master.c lhci_evt_enc_slave.c lhci_evt_phy.c lhci_evt_sc.c lhci_evt_vs.c lhci_init.c lhci_init_adv_master.c lhci_init_adv_master_ae.c lhci_init_adv_priv.c lhci_init_adv_slave.c lhci_init_adv_slave_ae.c lhci_init_conn.c lhci_init_conn_cs2.c lhci_init_conn_master.c lhci_init_conn_master_ae.c lhci_init_conn_priv.c lhci_init_enc_master.c lhci_init_enc_slave.c lhci_init_past.c lhci_init_phy.c lhci_init_sc.c lhci_main.c
    ../../../../controller/sources/ble/ll/: ll_init.c ll_init_adv_master.c ll_init_adv_master_ae.c ll_init_adv_slave.c ll_init_adv_slave_ae.c ll_init_conn_cs2.c ll_init_conn_master.c ll_init_conn_slave.c ll_init_enc_master.c ll_init_enc_slave.c ll_init_init_master.c ll_init_init_master_ae.c ll_init_master_phy.c ll_init_past.c ll_init_priv.c ll_init_sc.c ll_init_slave_phy.c ll_main.c ll_main_adv_master.c ll_main_adv_master_ae.c ll_main_adv_slave.c ll_main_adv_slave_ae.c ll_main_conn.c ll_main_conn_master.c ll_main_conn_master_ae.c ll_main_conn_slave.c ll_main_dtm.c ll_main_enc_master.c ll_main_enc_slave.c ll_main_past.c ll_main_phy.c ll_main_priv.c ll_main_sc.c ll_math.c
    ../../../../controller/sources/ble/lmgr/: lmgr_events.c lmgr_main.c lmgr_main_adv_master_ae.c lmgr_main_adv_slave_ae.c lmgr_main_conn.c lmgr_main_master.c lmgr_main_priv.c lmgr_main_sc.c lmgr_main_slave.c
    ../../../../controller/sources/ble/sch/: sch_ble.c sch_rm.c
    ../../../../controller/sources/common/sch/: sch_list.c sch_main.c
  group platform-external
    ../../../../platform/external/sources/audio_amp/: maxim9867.c
    ../../../../platform/external/sources/io_exp/: pca9557.c
  group platform-nordic
    ../../../../platform/nordic/sources/: pal_bb.c pal_bb_ble.c pal_bb_ble_rf.c pal_bb_ble_tester.c pal_btn.c pal_cfg.c pal_crypto.c pal_led.c pal_nvm.c pal_rtc.c pal_sys.c pal_timer.c pal_twi.c pal_uart.c
    ../../../../platform/nordic/build/: system_armcc_nrf52840.c
  group projects
    ../../../../projects/controller/ble5-ctr/: main.c
  group thirdparty
    ../../../../thirdparty/nordic-bsp/modules/nrfx/mdk/: arm_startup_nrf52840.s
    ../../../../thirdparty/nordic-bsp/external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
    ../../../../thirdparty/nordic-bsp/modules/nrfx/hal/: nrf_ecb.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../thirdparty/nordic-bsp/modules/nrfx/drivers/src/: nrfx_qspi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c
    ../../../../thirdparty/uecc/: uECC_ll.c
  group wsf
    ../../../../wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ../../../../wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_cs.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
